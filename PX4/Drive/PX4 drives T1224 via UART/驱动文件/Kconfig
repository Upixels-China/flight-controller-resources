## PX4/Drive/PX4 drives T1224 via UART/驱动文件/Kconfig
```kconfig
menuconfig DRIVERS_DISTANCE_SENSOR_TS1224
	bool "ts1224"
	default n
	---help---
		Enable support for ts1224
```
